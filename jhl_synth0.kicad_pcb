# Repository koyoi/jhl_synth0_pcb

## KiCad design jhl_synth0.kicad_pcb

Parts:
A1, A2: Arduino_Leonardo; Arduino_UNO_R3
A3: Arduino_Nano_v3.x; Arduino_Nano
D97, D98, D99, D100: LED_Small_Filled; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J3, J4, J11, J12, J13, J14, J15, J16, J17, J19, J21, J22, J23, J24, J25, J26, J28, J29, J45, J46, J47, J48: Conn_01x01; PinSocket_1x01_P2.54mm_Vertical
J2: USB_B_Micro; usb b micro jhl
J5, J6, J51: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J7, J8, J9, J10, J18, J27, J35, J52: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J20, J30: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
R1, R2, R3, R4: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U1: YAAJ_BlackPill; YAAJ_BlackPill_1
U2: YAAJ_BluePill; YAAJ_BluePill_1

Connections:
+3.3V: A3.17 (3V3), J20.1, J20.2, J20.3, J20.4, J20.5, J20.6, J20.7, J20.8, J20.9, J20.10, U1.16 (3V3); also elsewhere on the board
+5VP: A3.27 (+5V), J2.1 (VBUS); also elsewhere on the board
/pots/a0: J11.1; also elsewhere on the board
/pots/a1: J12.1; also elsewhere on the board
/pots/a2: J13.1; also elsewhere on the board
/pots/a3: J14.1; also elsewhere on the board
/pots/a4: J15.1; also elsewhere on the board
/pots/a5: J16.1; also elsewhere on the board
/pots/a6: J17.1; also elsewhere on the board
/pots/a7: J19.1; also elsewhere on the board
/pots/a8: J21.1; also elsewhere on the board
/pots/a9: J22.1; also elsewhere on the board
/pots/sw0: J23.1; also elsewhere on the board
/pots/sw1: J24.1; also elsewhere on the board
/pots/sw2: J25.1; also elsewhere on the board
/pots/sw3: J26.1; also elsewhere on the board
/pots/sw4: J28.1; also elsewhere on the board
/pots/sw5: J29.1; also elsewhere on the board
/pots/sw6: J45.1; also elsewhere on the board
/pots/sw7: J46.1; also elsewhere on the board
/pots/sw8: J47.1; also elsewhere on the board
/pots/sw9: J48.1; also elsewhere on the board
GND: D97.1 (K), D98.1 (K), D99.1 (K), D100.1 (K), J2.5 (GND), J30.1, J30.2, J30.3, J30.4, J30.5, J30.6, J30.7, J30.8, J30.9, J30.10; also elsewhere on the board
I2C_SCL: J27.1, J27.2, J27.3, J27.4; also elsewhere on the board
I2C_SDA: J18.1, J18.2, J18.3, J18.4; also elsewhere on the board
LED_C0_d: J51.1; also elsewhere on the board
LED_C1_d: J51.2; also elsewhere on the board
LED_C2_d: J51.3; also elsewhere on the board
LED_C3_d: J51.4; also elsewhere on the board
LED_C4_d: J51.5; also elsewhere on the board
LED_C5_d: J51.6; also elsewhere on the board
LED_C6_d: J51.7; also elsewhere on the board
LED_C7_d: J51.8; also elsewhere on the board
unnamed: A1.2 (IOREF), A2.2 (IOREF)
unnamed: A1.3 (~RESET), A2.3 (~RESET)
unnamed: A1.4 (3V3), A2.4 (3V3)
unnamed: A1.5 (+5V), A2.5 (+5V)
unnamed: A1.6 (GND), A2.6 (GND)
unnamed: A1.7 (GND), A2.7 (GND)
unnamed: A1.8 (VIN), A2.8 (VIN)
unnamed: A1.9 (A0), A2.9 (A0)
unnamed: A1.10 (A1), A2.10 (A1)
unnamed: A1.11 (A2), A2.11 (A2)
unnamed: A1.12 (A3), A2.12 (A3)
unnamed: A1.13 (A4), A2.13 (A4)
unnamed: A1.14 (A5), A2.14 (A5)
unnamed: A1.15 (D0/RX), A2.15 (D0/RX)
unnamed: A1.16 (D1/TX), A2.16 (D1/TX)
unnamed: A1.17 (D2/SDA), A2.17 (D2/SDA)
unnamed: A1.18 (D3/SCL), A2.18 (D3/SCL)
unnamed: A1.19 (D4), A2.19 (D4)
unnamed: A1.20 (D5), A2.20 (D5)
unnamed: A1.21 (D6), A2.21 (D6)
unnamed: A1.22 (D7), A2.22 (D7)
unnamed: A1.23 (D8), A2.23 (D8)
unnamed: A1.24 (D9), A2.24 (D9)
unnamed: A1.25 (D10), A2.25 (D10)
unnamed: A1.26 (D11), A2.26 (D11)
unnamed: A1.27 (D12), A2.27 (D12)
unnamed: A1.28 (D13), A2.28 (D13)
unnamed: A1.29 (GND), A2.29 (GND)
unnamed: A1.30 (AREF), A2.30 (AREF)
unnamed: A1.31 (SDA/D2), A2.31 (SDA/D2)
unnamed: A1.32 (SCL/D3), A2.32 (SCL/D3)
unnamed: D97.2 (A), R1.2
unnamed: D98.2 (A), R2.2
unnamed: D99.2 (A), R3.2
unnamed: D100.2 (A), R4.2
unnamed: J1.1, J2.3 (D+)
unnamed: J2.2 (D-), J3.1
unnamed: J2.4 (ID), J4.1
unnamed: J5.1, J6.1
unnamed: J5.2, J6.2
unnamed: J5.3, J6.3
unnamed: J5.4, J6.4
unnamed: J5.5, J6.5
unnamed: J5.6, J6.6
unnamed: J5.7, J6.7
unnamed: J5.8, J6.8
unnamed: J7.1, J8.1
unnamed: J7.2, J8.2
unnamed: J7.3, J8.3
unnamed: J7.4, J8.4
unnamed: J9.1, J10.1, J52.1
unnamed: J9.2, J10.2, J52.2
unnamed: J9.3, J10.3, J52.3
unnamed: J9.4, J10.4, J52.4
unnamed: J35.1, R1.1
unnamed: J35.2, R2.1
unnamed: J35.3, R3.1
unnamed: J35.4, R4.1

Notes on the sheet:
I2C for LCD
通常（device) 解放
blue/black pill ではavrefがvdd3.3固定
GROVE SCL SDA Vcc GND
SPI for LCD

Parts:
C1: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96: LED_Small_Filled; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D101: BU5004
IC1: HT16K33
J36, J40, J49: Conn_01x02; PinHeader_2x01_P2.54mm_Vertical
J53: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
R5, R6, R7, R8, R9, R10, R11, R12, R13: 200k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U3, U4, U7: SA39-12SRWA; Sx39-1xxxxx
U5: PCA9306DC; VSSOP-8_2.3x2mm_P0.5mm
U6: PCA9306DP; TSSOP-8_3x3mm_P0.65mm
U8: PCA9306D; SO-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: U5.2 (VREF1), U6.2 (VREF1), U8.2 (VREF1); also elsewhere on the board
+5VP: C1.1, IC1.24 (VDD), R5.2, U5.7 (VREF2), U6.7 (VREF2), U8.7 (VREF2); also elsewhere on the board
GND: C1.2, IC1.1 (VSS), U5.1 (GND), U6.1 (GND), U8.1 (GND); also elsewhere on the board
I2C_SCL: U5.3 (SCL1), U6.3 (SCL1), U8.3 (SCL1); also elsewhere on the board
I2C_SCL5: IC1.22 (SCL), U5.6 (SCL2), U6.6 (SCL2), U8.6 (SCL2)
I2C_SDA: U5.4 (SDA1), U6.4 (SDA1), U8.4 (SDA1); also elsewhere on the board
I2C_SDA5: IC1.23 (SDA), U5.5 (SDA2), U6.5 (SDA2), U8.5 (SDA2)
LED_C0: D1.1 (K), D9.1 (K), D17.1 (K), D25.1 (K), D33.1 (K), D41.1 (K), D49.1 (K), D57.1 (K), D65.1 (K), D73.1 (K), D81.1 (K), D89.1 (K), D101.7 (COL1), IC1.2 (COM0/AD), J53.2, U3.10 (A), U4.10 (A), U7.10 (A)
LED_C0_d: R6.2; also elsewhere on the board
LED_C1: D2.1 (K), D10.1 (K), D18.1 (K), D26.1 (K), D34.1 (K), D42.1 (K), D50.1 (K), D58.1 (K), D66.1 (K), D74.1 (K), D82.1 (K), D90.1 (K), D101.4 (COL2), IC1.3 (COM1/KS0), J53.4, U3.9 (B), U4.9 (B), U7.9 (B)
LED_C1_d: R7.2; also elsewhere on the board
LED_C2: D3.1 (K), D11.1 (K), D19.1 (K), D27.1 (K), D35.1 (K), D43.1 (K), D51.1 (K), D59.1 (K), D67.1 (K), D75.1 (K), D83.1 (K), D91.1 (K), D101.3 (COL3), IC1.4 (COM2/KS1), J53.6, U3.8 (C), U4.8 (C), U7.8 (C)
LED_C2_d: R8.2; also elsewhere on the board
LED_C3: D4.1 (K), D12.1 (K), D20.1 (K), D28.1 (K), D36.1 (K), D44.1 (K), D52.1 (K), D60.1 (K), D68.1 (K), D76.1 (K), D84.1 (K), D92.1 (K), D101.2 (COL4), IC1.5 (COM3/KS2), J53.8, U3.5 (D), U4.5 (D), U7.5 (D)
LED_C3_d: R9.2; also elsewhere on the board
LED_C4: D5.1 (K), D13.1 (K), D21.1 (K), D29.1 (K), D37.1 (K), D45.1 (K), D53.1 (K), D61.1 (K), D69.1 (K), D77.1 (K), D85.1 (K), D93.1 (K), D101.10 (COL5), IC1.6 (COM4), J53.10, U3.4 (E), U4.4 (E), U7.4 (E)
LED_C4_d: R10.2; also elsewhere on the board
LED_C5: D6.1 (K), D14.1 (K), D22.1 (K), D30.1 (K), D38.1 (K), D46.1 (K), D54.1 (K), D62.1 (K), D70.1 (K), D78.1 (K), D86.1 (K), D94.1 (K), D101.11 (COL6), IC1.7 (COM5), J53.12, U3.2 (F), U4.2 (F), U7.2 (F)
LED_C5_d: R11.2; also elsewhere on the board
LED_C6: D7.1 (K), D15.1 (K), D23.1 (K), D31.1 (K), D39.1 (K), D47.1 (K), D55.1 (K), D63.1 (K), D71.1 (K), D79.1 (K), D87.1 (K), D95.1 (K), D101.12 (COL7), IC1.8 (COM6), J53.14, U3.3 (G), U4.3 (G), U7.3 (G)
LED_C6_d: R12.2; also elsewhere on the board
LED_C7: D8.1 (K), D16.1 (K), D24.1 (K), D32.1 (K), D40.1 (K), D48.1 (K), D56.1 (K), D64.1 (K), D72.1 (K), D80.1 (K), D88.1 (K), D96.1 (K), D101.15 (COL8), IC1.9 (COM7), J53.16, U3.7 (DP), U4.7 (DP), U7.7 (DP)
LED_C7_d: R13.2; also elsewhere on the board
LED_R0: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D101.16 (ROW1), IC1.21 (ROW0/A1)
LED_R1: D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D101.1 (ROW2), IC1.20 (ROW1/A0)
LED_R2: D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D101.14 (ROW3), IC1.19 (ROW2/K1)
LED_R3: D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), D31.2 (A), D32.2 (A), D101.13 (ROW4), IC1.18 (ROW3/K2)
LED_R4: D33.2 (A), D34.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), D39.2 (A), D40.2 (A), D101.5 (ROW5), IC1.17 (ROW4/K3)
LED_R5: D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), D46.2 (A), D47.2 (A), D48.2 (A), D101.6 (ROW6), IC1.16 (ROW5/K4)
LED_R6: D49.2 (A), D50.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), D55.2 (A), D56.2 (A), D101.9 (ROW7), IC1.15 (ROW6/K5)
LED_R7: D57.2 (A), D58.2 (A), D59.2 (A), D60.2 (A), D61.2 (A), D62.2 (A), D63.2 (A), D64.2 (A), D101.8 (ROW8), IC1.14 (ROW7/K6)
LED_R8: D65.2 (A), D66.2 (A), D67.2 (A), D68.2 (A), D69.2 (A), D70.2 (A), D71.2 (A), D72.2 (A), IC1.13 (ROW8/K7), J36.1
LED_R9: D73.2 (A), D74.2 (A), D75.2 (A), D76.2 (A), D77.2 (A), D78.2 (A), D79.2 (A), D80.2 (A), IC1.12 (ROW9/K8), J40.1
LED_R10: D81.2 (A), D82.2 (A), D83.2 (A), D84.2 (A), D85.2 (A), D86.2 (A), D87.2 (A), D88.2 (A), IC1.11 (ROW10/K9), J49.1
LED_R11: D89.2 (A), D90.2 (A), D91.2 (A), D92.2 (A), D93.2 (A), D94.2 (A), D95.2 (A), D96.2 (A), IC1.10 (ROW11/K10/INT)
unnamed: J36.2, U4.1 (CA), U4.6 (CA)
unnamed: J40.2, U3.1 (CA), U3.6 (CA)
unnamed: J49.2, U7.1 (CA), U7.6 (CA)
unnamed: J53.1, R6.1
unnamed: J53.3, R7.1
unnamed: J53.5, R8.1
unnamed: J53.7, R9.1
unnamed: J53.9, R10.1
unnamed: J53.11, R11.1
unnamed: J53.13, R12.1
unnamed: J53.15, R13.1
unnamed: R5.1, U5.8 (EN), U6.8 (EN), U8.8 (EN)

Parts:
J34: Conn_01x01; PinSocket_1x01_P2.54mm_Vertical
RV1, RV3, RV5, RV7, RV9, RV11, RV13, RV15, RV17, RV19: R_Potentiometer; Potentiometer_Vishay_T73YP_Vertical
RV2, RV4, RV6, RV8, RV10, RV12, RV14, RV16, RV18, RV20: R_Potentiometer; Potentiometer_Vishay_T93YA_Vertical
SW1, SW3, SW5, SW7, SW9, SW11, SW13, SW15, SW17, SW19: SW_SPST; SW_Push_1P1T_XKB_TS-1187A
SW2, SW4, SW6, SW8, SW10, SW12, SW14, SW16, SW18, SW20: SW_SPST; SW_TH_Tactile_Omron_B3F-100x

Connections:
/pots/a0: RV1.2, RV2.2; also elsewhere on the board
/pots/a1: RV9.2, RV10.2; also elsewhere on the board
/pots/a2: RV15.2, RV16.2; also elsewhere on the board
/pots/a3: RV17.2, RV18.2; also elsewhere on the board
/pots/a4: RV3.2, RV4.2; also elsewhere on the board
/pots/a5: RV7.2, RV8.2; also elsewhere on the board
/pots/a6: RV13.2, RV14.2; also elsewhere on the board
/pots/a7: RV19.2, RV20.2; also elsewhere on the board
/pots/a8: RV5.2, RV6.2; also elsewhere on the board
/pots/a9: RV11.2, RV12.2; also elsewhere on the board
/pots/sw0: SW1.1 (A), SW2.1 (A); also elsewhere on the board
/pots/sw1: SW3.1 (A), SW4.1 (A); also elsewhere on the board
/pots/sw2: SW5.1 (A), SW6.1 (A); also elsewhere on the board
/pots/sw3: SW7.1 (A), SW8.1 (A); also elsewhere on the board
/pots/sw4: SW9.1 (A), SW10.1 (A); also elsewhere on the board
/pots/sw5: SW11.1 (A), SW12.1 (A); also elsewhere on the board
/pots/sw6: SW13.1 (A), SW14.1 (A); also elsewhere on the board
/pots/sw7: SW15.1 (A), SW16.1 (A); also elsewhere on the board
/pots/sw8: SW17.1 (A), SW18.1 (A); also elsewhere on the board
/pots/sw9: SW19.1 (A), SW20.1 (A); also elsewhere on the board
GND: RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, RV11.3, RV12.3, RV13.3, RV14.3, RV15.3, RV16.3, RV17.3, RV18.3, RV19.3, RV20.3, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.2 (B), SW5.2 (B), SW6.2 (B), SW7.2 (B), SW8.2 (B), SW9.2 (B), SW10.2 (B), SW11.2 (B), SW12.2 (B), SW13.2 (B), SW14.2 (B), SW15.2 (B), SW16.2 (B), SW17.2 (B), SW18.2 (B), SW19.2 (B), SW20.2 (B); also elsewhere on the board
avref: J34.1, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, RV11.1, RV12.1, RV13.1, RV14.1, RV15.1, RV16.1, RV17.1, RV18.1, RV19.1, RV20.1

Parts:
J31, J32, J33, J37, J38, J39: Conn_01x20; PinSocket_1x20_P2.54mm_Vertical
J41, J44: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
J42, J43: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical

Connections:
unnamed: J31.1, J38.1, J39.1
unnamed: J31.2, J38.2, J39.2
unnamed: J31.3, J38.3, J39.3
unnamed: J31.4, J38.4, J39.4
unnamed: J31.5, J38.5, J39.5
unnamed: J31.6, J38.6, J39.6
unnamed: J31.7, J38.7, J39.7
unnamed: J31.8, J38.8, J39.8
unnamed: J31.9, J38.9, J39.9
unnamed: J31.10, J38.10, J39.10
unnamed: J31.11, J38.11, J39.11
unnamed: J31.12, J38.12, J39.12
unnamed: J31.13, J38.13, J39.13
unnamed: J31.14, J38.14, J39.14
unnamed: J31.15, J38.15, J39.15
unnamed: J31.16, J38.16, J39.16
unnamed: J31.17, J38.17, J39.17
unnamed: J31.18, J38.18, J39.18
unnamed: J31.19, J38.19, J39.19
unnamed: J31.20, J38.20, J39.20
unnamed: J32.1, J33.1, J37.1
unnamed: J32.2, J33.2, J37.2
unnamed: J32.3, J33.3, J37.3
unnamed: J32.4, J33.4, J37.4
unnamed: J32.5, J33.5, J37.5
unnamed: J32.6, J33.6, J37.6
unnamed: J32.7, J33.7, J37.7
unnamed: J32.8, J33.8, J37.8
unnamed: J32.9, J33.9, J37.9
unnamed: J32.10, J33.10, J37.10
unnamed: J32.11, J33.11, J37.11
unnamed: J32.12, J33.12, J37.12
unnamed: J32.13, J33.13, J37.13
unnamed: J32.14, J33.14, J37.14
unnamed: J32.15, J33.15, J37.15
unnamed: J32.16, J33.16, J37.16
unnamed: J32.17, J33.17, J37.17
unnamed: J32.18, J33.18, J37.18
unnamed: J32.19, J33.19, J37.19
unnamed: J32.20, J33.20, J37.20
unnamed: J41.1, J44.1
unnamed: J41.2, J44.2
unnamed: J41.3, J44.3
unnamed: J41.4, J44.4
unnamed: J41.5, J44.5
unnamed: J41.6, J44.6
unnamed: J41.7, J44.7
unnamed: J41.8, J44.8
unnamed: J41.9, J44.9
unnamed: J41.10, J44.10
unnamed: J42.1, J43.1
unnamed: J42.2, J43.2
unnamed: J42.3, J43.3
unnamed: J42.4, J43.4
unnamed: J42.5, J43.5
unnamed: J42.6, J43.6
unnamed: J42.7, J43.7
unnamed: J42.8, J43.8

Board: 4 copper layers, 100.0 x 100.0 mm, 218 parts (2 on the bottom side), 153 nets.

## Commit log

2025-10-19 init
2025-10-20 仮回路、仮配置
2025-10-21 日々の進捗
2025-10-23 251023
2025-10-30 prl 対象外
